# Keil uVision project Test_89C4051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C4051 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: Test_89C4051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 test.c
